# Keil uVision project version2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: version2 +hex
  c flags: Optimize=9 SizeSpeed=1
  group New Group
    ./: DS18B20.c LCD.c main.c SGP30.c uart.c SIM800.c
